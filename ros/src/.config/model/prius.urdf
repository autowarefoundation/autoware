Commit message: Add Tier4 vehicle model

File: ros/src/.config/model/prius.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://model_publisher/../../../.config/model/prius.dae scale=1.0 1.0 1.0
