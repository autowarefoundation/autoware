Commit message: fix typoe

File: ros/src/vehicle/vehicle_description/urdf/xe.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://vehicle_description/mesh/xe.dae scale=1.0 1.0 1.0
